inherit pypi setuptools3
require python-futures.inc
